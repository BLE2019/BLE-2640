# IAR project cc2650em_app.ewp, settings and files
configuration FlashROM_TFT (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RGZ; CC26XX; GAPCENTRALROLE_NUM_RSSI_LINKS=1; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xDisplay_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; SCANBEACON_ADVANCE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\source\profile; ..\..\stack; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RGZ; ..\..\source\driver\pwm; ..\..\source\driver\i2c; ..\..\source\driver\bma250e; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\adc; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\bma250e; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\app; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\gpio; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\GT20L16S1Y; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\i2c; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\lcd; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\OLED; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\pwm; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\SLEEP; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\spi; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\uart; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\WDT; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\WDT\watchdog; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1\crypto; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1\mac; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1\module; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1\ports; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_scanibeacon_base\source\driver\LoRaMac1\radio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\source\driver\pwm; ..\..\source\driver\i2c; ..\..\source\driver\bma250e
  OBJCOPY.OOCOutputFile: simple_central_cc2650em_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_central_cc2650em_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_ePaper (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RGZ; CC26XX; GAPCENTRALROLE_NUM_RSSI_LINKS=1; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xDisplay_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\source\profile; ..\..\stack; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RGZ
configuration FlashROM_NoDisply (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: cc2650em_app.out
  group Application
    ../../../target/LAUNCHIOT_CC2650_RGZ/: iotboard_key.c iotboard_key.h
    ../../source/app/: simple_central.c simple_central.h
    ../../../../../src/common/cc26xx/: util.c Util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayDogm1286.c DisplayDogm1286.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    ../../../../../src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/LORA
    ../../source/app/: lora_support.c lora_support.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    ../../../../../src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group GY_SerialPort/ADC
    ../../source/driver/adc/: aux_adc.c aux_adc.h
  group GY_SerialPort/bma
    ../../source/driver/bma250e/: hw_bma250e.c hw_bma250e.h hw_bma250e_Spec.h
  group GY_SerialPort/GPIO
    ../../source/driver/gpio/: hw_gpio.c hw_gpio.h
  group GY_SerialPort/GT20L16S1Y
    ../../source/driver/GT20L16S1Y/: GT20L16S1Y.c GT20L16S1Y.h
  group GY_SerialPort/i2c
    ../../source/driver/i2c/: hw_i2c.c hw_i2c.h
  group GY_SerialPort/LCD
    ../../source/driver/lcd/: TFT128.c TFT128.h
  group GY_SerialPort/LoRaMac
    ../../source/driver/LoRaMac1/: Comm2Trm.c Network.c
  group GY_SerialPort/LoRaMac/crypto
    ../../source/driver/LoRaMac1/crypto/: aes.c aes.h cmac.c cmac.h vssver2.scc
  group GY_SerialPort/LoRaMac/mac
    ../../source/driver/LoRaMac1/mac/: LoRaMac-definitions.h LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacTest.h vssver2.scc
  group GY_SerialPort/LoRaMac/module
    ../../source/driver/LoRaMac1/module/: SchedTimer.c SchedTimer.h utilities.c utilities.h vssver2.scc
  group GY_SerialPort/LoRaMac/ports
    ../../source/driver/LoRaMac1/ports/: radio.h RFAdapter.c RFAdapter.h RtcAdapter.c RtcAdapter.h vssver2.scc
  group GY_SerialPort/LoRaMac/radio
    ../../source/driver/LoRaMac1/radio/: sx1276Regs-Fsk.h sx1276Regs-LoRa.h sx1278_ports.c sx1278_ports.h sx1278_src.c sx1278_src.h vssver2.scc
  group GY_SerialPort/OLED
    ../../source/driver/OLED/: oled.c oled.h
  group GY_SerialPort/pwm
    ../../source/driver/pwm/: hw_pwm.c hw_pwm.h music.h
  group GY_SerialPort/SPI
    ../../source/driver/spi/: hw_spi.c hw_spi.h osal_snv.h
  group GY_SerialPort/UART
    ../../source/driver/uart/: task_uart.c task_uart.h
  group GY_SerialPort/WDT
    ../../source/driver/WDT/: watchdog.c watchdog.h watchdog_doc.h
  group ICall
    ../../../../../src/components/heapmgr/: heapmgr.h
    ../../../../../src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    ../../../../../src/components/icall/src/inc/: icall.h
    ../../../../../src/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../src/icall/app/: ble_user_config.c icall_api.c
    ../../../../../src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../src/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../src/profiles/roles/: gapbondmgr.h
    ../../../../../src/components/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../src/profiles/roles/cc26xx/: central.c central.h
  group Startup
    ../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../source/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../src/common/cc26xx/iar/: cc26xx_app.icf
