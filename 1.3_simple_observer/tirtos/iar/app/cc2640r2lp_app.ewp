# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $EXAMPLE_BLE_ROOT$\..\target; $EXAMPLE_BLE_ROOT$\..\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\..\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\..\common\display; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\spi; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\i2c; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\bma250e; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\uart; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\GT20L16S1Y; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\TFT_touch; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\rtc; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\oxygen; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\rtc; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\source\ti\ble5stack\common\cc26xx\time; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\examples\rtos\CC2640R2_LAUNCHIOT\ble5stack\1.3_simple_observer\src\driver\pwm; C:\ti\simplelink_cc2640r2_sdk_1_40_00_45\kernel\tirtos\packages\ti\sysbios\hal
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble5_simple_observer_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary_ePaper (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=1; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2MOD_RGZ; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; POWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $EXAMPLE_BLE_ROOT$\..\target; $EXAMPLE_BLE_ROOT$\..\target\cc2640r2iot; $EXAMPLE_BLE_ROOT$\..\target\LAUNCHIOT_CC2640R2MOD_RGZ; $EXAMPLE_BLE_ROOT$\src\driver\gpio; $EXAMPLE_BLE_ROOT$\..\common\display
  group Application
    ../../../../target/: iotboard_key.c iotboard_key.h
    ../../../src/app/: simple_observer.c simple_observer.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/: util.c util.h
  group Drivers/bma250e
    ../../../src/driver/bma250e/: count_steps.c count_steps.h hw_bma250e.c hw_bma250e.h hw_bma250e_Spec.h
  group Drivers/ECC
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/GT20L16S1Y
    ../../../src/driver/GT20L16S1Y/: GT20L16S1Y.c GT20L16S1Y.h
  group Drivers/i2c
    ../../../src/driver/i2c/: hw_i2c.c hw_i2c.h
  group Drivers/oxygen
    ../../../src/driver/oxygen/: algorithm.c algorithm.h oxygen.c oxygen.h
  group Drivers/pwm
    ../../../src/driver/pwm/: hw_pwm.c hw_pwm.h
  group Drivers/rtc
    ../../../src/driver/rtc/: gua_rtc.c GUA_RTC.h
  group Drivers/spi
    ../../../src/driver/spi/: hw_spi.c hw_spi.h
  group Drivers/TFT_touch
    ../../../src/driver/TFT_touch/: LCDFONT.h TFT_touch.c TFT_touch.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/ble5stack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/uart
    ../../../src/driver/uart/: hw_uart.c hw_uart.h
  group GY_Serial
    ../../../../common/display/: DisplayEPD200.h DisplayTFT128.h EPD200.h lcd_epd_lib_r2.a lcd_tft_lib_r2.a TFT128.h
    ../../../src/driver/gpio/: hw_gpio.c hw_gpio.h
  group ICall
    ../../../../../../../../source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/ble5stack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/ble5stack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/ble5stack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/ble5stack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    ../../../../../../../../source/ti/ble5stack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/ble5stack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/ble5stack/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../../../../source/ti/ble5stack/profiles/roles/cc26xx/: observer.c observer.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    ../../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/iar/: cc26xx_app_and_stack.icf
