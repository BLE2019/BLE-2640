# IAR project cc2650lp_app.ewp, settings and files
configuration FlashROM_TFT (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RGZ; CC26XX; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_TFT; BEACON_ADVANCE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\profile; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RGZ; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\app; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\adc; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\bma250e; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\display; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\gpio; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\i2c; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\lcd; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\oxygen; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\sht20; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\SLEEP; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\uart; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\WDT; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\WDT\watchdog; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\bmp280; C:\ti\simplelink\ble_sdk_2_02_01_18\examples\cc2650iot\0.17_advance_ibeacon\source\driver\DS1302
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2650lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_peripheral_cc2650lp_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_ePaper (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC2650MOD_RGZ; CC26XX; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; PROFILE_Multibyte; IOTXX_DISPLAY_EPD
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/dev_info; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ..\..\source\app; ..\..\source\profile; ..\..\source\driver\uart; ..\..\source\driver\gpio; ..\..\..\common\display; ..\..\..\target\LAUNCHIOT_CC2650_RGZ
  group Application
    ../../../target/LAUNCHIOT_CC2650_RGZ/: iotboard_key.c iotboard_key.h
    ../../../../../src/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    ../../source/app/: simple_peripheral.c simple_peripheral.h
    ../../../../../src/common/cc26xx/: util.c Util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    ../../../../../src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/TRNG
    ../../../../../src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group Drivers/WDT
    ../../source/driver/WDT/: watchdog.c watchdog.h watchdog_doc.h
    ../../source/driver/WDT/watchdog/: WatchdogCC26XX.c WatchdogCC26XX.h
  group GY_SerialPort/ADC
    ../../source/driver/adc/: hw_adc.c hw_adc.h
  group GY_SerialPort/BMA
    ../../source/driver/bma250e/: hw_bma250e.c hw_bma250e.h hw_bma250e_Spec.h
  group GY_SerialPort/BMP280
    ../../source/driver/bmp280/: sensor_bmp280.c sensor_bmp280.h
  group GY_SerialPort/DS1302
    ../../source/driver/DS1302/: ds1302.c ds1302.h
  group GY_SerialPort/GPIO
    ../../source/driver/gpio/: hw_gpio.c hw_gpio.h
  group GY_SerialPort/I2C
    ../../source/driver/i2c/: hw_i2c.c hw_i2c.h
  group GY_SerialPort/LCD
    ../../../common/display/: DisplayEPD200.h DisplayTFT128.h EPD200.h lcd_epd_lib.a lcd_tft_lib.a TFT128.h
  group GY_SerialPort/OXYGEN
    ../../source/driver/oxygen/: algorithm.c algorithm.h oxygen.c oxygen.h
  group GY_SerialPort/SHT20
    ../../source/driver/sht20/: sensor_sht21.c sensor_sht21.h
  group GY_SerialPort/UART
    ../../source/driver/uart/: hw_uart.c hw_uart.h
  group ICall
    ../../../../../src/components/heapmgr/: heapmgr.h
    ../../../../../src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    ../../../../../src/components/icall/src/inc/: icall.h
    ../../../../../src/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../src/icall/app/: ble_user_config.c icall_api.c
    ../../../../../src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../src/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../src/profiles/roles/: gapbondmgr.h
    ../../../../../src/components/osal/src/inc/: osal_snv.h
  group Middleware/extflash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Profiles
    ../../../../../src/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../src/profiles/dev_info/: devinfoservice.h
    ../../../../../src/common/cc26xx/: ext_flash_layout.h
    ../../../../../src/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../src/host/: gatt_uuid.c gattservapp_util.c
    ../../source/profile/: iBeaconProfile.c iBeaconProfile.h simple_gatt_profile.c simple_gatt_profile.h
    ../../../../../src/profiles/oad/cc26xx/: oad.c oad.h oad_reset_service.c oad_target_external_flash.c oad_target_internal_flash.c
    ../../../../../src/profiles/roles/cc26xx/: peripheral.c peripheral.h
    ../../../../../src/profiles/keys/cc26xx/: simplekeys.c
    ../../../../../src/profiles/keys/: simplekeys.h
  group Startup
    ../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../../../src/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../source/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../src/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
